# Repository myriadrf/LMS6002-Pmod

File README.md:

This is the repository of the Pmod™ compatible SDR board with an
LMS6002 FPRF. For more information visit the
[website](https://wiki.myriadrf.org/LMS6002_Pmod).

## KiCad design board/KiCad/LMS6002-Pmod.kicad_pcb

Schematic: LMS6002-Pmod.sch

Parts:
T1: OSHW_Logo; Symbol_OSHW-Logo_SilkScreen

Parts:
P1: PMOD_2x6; Pmod
P2: PMOD_2x6; Pmod_no_header

Connections:
3V3_PMOD: P1.6, P1.12, P2.6, P2.12; also elsewhere on the board
GND: P1.5, P1.11, P2.5, P2.11; also elsewhere on the board
PIO0: P1.1; also elsewhere on the board
PIO1: P1.2; also elsewhere on the board
PIO2: P1.3; also elsewhere on the board
PIO3: P1.4; also elsewhere on the board
PIO4: P1.7; also elsewhere on the board
PIO5: P1.8; also elsewhere on the board
PIO6: P1.9; also elsewhere on the board
PIO7: P1.10; also elsewhere on the board
PIO8: P2.1; also elsewhere on the board
PIO9: P2.2; also elsewhere on the board
PIO10: P2.3; also elsewhere on the board
PIO11: P2.4; also elsewhere on the board
PIO12: P2.7; also elsewhere on the board
PIO13: P2.8; also elsewhere on the board
PIO14: P2.9; also elsewhere on the board
PIO15: P2.10; also elsewhere on the board

Notes on the sheet:
This is the board connector
This is the extra breakout

Parts:
C1, C6, C10: 10µF; C_0603_HandSoldering
C2, C8, C12: 0.1µF; C_0603_HandSoldering
C7, C11: 1µF; C_0603_HandSoldering
C9, C13: 0.01µF; C_0603_HandSoldering
C14, C15, C16, C17, C18, C19, C20, C21, C22, C23: 100n; C_0603_HandSoldering
D2: Schottky 0520; SOD-123_Handsoldering
D3, D4, D5, D6: LED; SMD-1206_Pol
R1: 100; R_0603_HandSoldering
R2, R3, R4, R8: 10; R_0603_HandSoldering
R7, R12: 10K; R_0603_HandSoldering
SW1: ICE_RESET; B3U-1000P_Handsoldering; Manufacturer Part Number B3U-1000P
U1: iCE40_1K4K_TQ144; TQFP-144_20x20mm_Pitch0.5mm

Connections:
1V2_LDO: C6.1, C7.1, C8.1, C9.1, C16.1, C18.1, C20.1, C22.1, R1.1, U1.27 (VCC), U1.51 (VCC), U1.92 (VCC), U1.111 (VCC); also elsewhere on the board
3V3_PMOD: C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C17.1, C19.1, C21.1, C23.1, D2.2 (A), R7.1, R12.1, U1.6 (VCCIO_3), U1.30 (VCCIO_3), U1.72 (VCC_SPI), U1.89 (VCCIO_1), U1.100 (VCCIO_1), U1.123 (VCCIO_0), U1.133 (VCCIO_0); also elsewhere on the board
DIQ1_D0: U1.74 (IOR_49_110); also elsewhere on the board
DIQ1_D1: U1.78 (IOR_52_114); also elsewhere on the board
DIQ1_D2: U1.75 (IOR_50_111); also elsewhere on the board
DIQ1_D3: U1.79 (IOR_53_115); also elsewhere on the board
DIQ1_D4: U1.76 (IOR_51_112); also elsewhere on the board
DIQ1_D5: U1.80 (IOR_54_116); also elsewhere on the board
DIQ1_D6: U1.87 (IOR_56_136); also elsewhere on the board
DIQ1_D7: U1.81 (IOR_55_117); also elsewhere on the board
DIQ1_D8: U1.88 (IOR_57_137); also elsewhere on the board
DIQ1_D9: U1.91 (IOR_59_139); also elsewhere on the board
DIQ1_D10: U1.90 (IOR_58_138); also elsewhere on the board
DIQ1_D11: U1.93 (IOR_60_140); also elsewhere on the board
DIQ1_SEL: U1.73 (IOR_48_109); also elsewhere on the board
DIQ2_D0: U1.97 (IOR_64_147); also elsewhere on the board
DIQ2_D1: U1.94 (IOR_61_141); also elsewhere on the board
DIQ2_D2: U1.99 (IOR_66_152); also elsewhere on the board
DIQ2_D3: U1.95 (IOR_62_144); also elsewhere on the board
DIQ2_D4: U1.101 (IOR_67_160); also elsewhere on the board
DIQ2_D5: U1.98 (IOR_65_148); also elsewhere on the board
DIQ2_D6: U1.105 (IOR_70_165); also elsewhere on the board
DIQ2_D7: U1.102 (IOR_68_161); also elsewhere on the board
DIQ2_D8: U1.106 (IOR_71_166); also elsewhere on the board
DIQ2_D9: U1.104 (IOR_69_164); also elsewhere on the board
DIQ2_D10: U1.107 (IOR_72_167); also elsewhere on the board
DIQ2_D11: U1.113 (IOT_74_170); also elsewhere on the board
DIQ2_SEL: U1.96 (IOR_63_146); also elsewhere on the board
EXT_SPI_CLK: U1.70 (SCK); also elsewhere on the board
EXT_SPI_MISO: U1.68 (SDI); also elsewhere on the board
EXT_SPI_MOSI: U1.67 (SDO); also elsewhere on the board
EXT_SPI_SS_B: U1.71 (SS); also elsewhere on the board
FCLK1: U1.114 (IOT_75_171); also elsewhere on the board
FCLK2: U1.112 (IOT_73_169); also elsewhere on the board
GND: C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), SW1.1 (Base), U1.5 (GND), U1.13 (GND), U1.14 (GND), U1.59 (GND), U1.69 (GND), U1.86 (GND), U1.103 (GND), U1.132 (GND), U1.140 (GND); also elsewhere on the board
ICE_CDONE: R7.2, R8.1, U1.65 (CDONE)
ICE_CLK_IN: U1.21 (GBIN6); also elsewhere on the board
ICE_CRESET_B: R12.2, SW1.2 (Coll), U1.66 (CRESET_B)
unnamed: C1.1, C2.1, U1.35 (GNDPLL)
unnamed: C1.2, C2.2, R1.2, U1.36 (VCCPLL)
unnamed: D2.1 (K), U1.109 (VPP_FAST)
unnamed: D3.2 (A), R2.1
unnamed: D4.2 (A), R3.1
unnamed: D5.2 (A), R4.1
unnamed: D6.2 (A), R8.2
unnamed: R2.2, U1.142 (IOT_94_220)
unnamed: R3.2, U1.143 (IOT_95_221)
unnamed: R4.2, U1.144 (IOT_96_222)
PIO0: U1.11 (IOL_5A_8A); also elsewhere on the board
PIO1: U1.19 (IOL_6A_13A); also elsewhere on the board
PIO2: U1.22 (IOL_7B_14B); also elsewhere on the board
PIO3: U1.24 (IOL_8B_17B); also elsewhere on the board
PIO4: U1.12 (IOL_5B_8B); also elsewhere on the board
PIO5: U1.20 (IOL_6B_13B); also elsewhere on the board
PIO6: U1.23 (IOL_8A_17A); also elsewhere on the board
PIO7: U1.25 (IOL_9A_18A); also elsewhere on the board
PIO8: U1.7 (IOL_3A_4A); also elsewhere on the board
PIO9: U1.8 (IOL_3B_4B); also elsewhere on the board
PIO10: U1.9 (IOL_4A_5A); also elsewhere on the board
PIO11: U1.10 (IOL_4B_5B); also elsewhere on the board
PIO12: U1.3 (IOL_2A_3A); also elsewhere on the board
PIO13: U1.2 (IOL_1B_2B); also elsewhere on the board
PIO14: U1.1 (IOL_1A_2A); also elsewhere on the board
PIO15: U1.4 (IOL_2B_3B); also elsewhere on the board
RFDIO_GPIO0: U1.118 (IOT_79_177); also elsewhere on the board
RFDIO_GPIO1: U1.119 (IOT_80_178); also elsewhere on the board
RFDIO_GPIO2: U1.120 (IOT_81_179); also elsewhere on the board
RFDIO_REF_CLK_IN: U1.121 (IOT_82_181); also elsewhere on the board
RFDIO_RESET: U1.115 (IOT_76_172); also elsewhere on the board
RFDIO_SPI_CLK: U1.128 (IOT_84_197); also elsewhere on the board
RFDIO_SPI_EN: U1.129 (IOT_85_198); also elsewhere on the board
RFDIO_SPI_MISO: U1.117 (IOT_78_174); also elsewhere on the board
RFDIO_SPI_MOSI: U1.116 (IOT_77_173); also elsewhere on the board
RXEN: U1.134 (IOT_87_212); also elsewhere on the board
TXEN: U1.122 (IOT_83_190); also elsewhere on the board

Notes on the sheet:
LED prog. done
ICE reset
Filter
Place near to Pins

Schematic: myriadrf.sch

Parts:
J1: FX10B_80S_8; Manufacturer Part Number FX10B-80S/8-SV(71)
P3, P4: Myriad_Mount_Hole

Connections:
5V: J1.1, J1.2, J1.3, J1.4; also elsewhere on the board
DIQ1_D0: J1.23; also elsewhere on the board
DIQ1_D1: J1.24; also elsewhere on the board
DIQ1_D2: J1.25; also elsewhere on the board
DIQ1_D3: J1.26; also elsewhere on the board
DIQ1_D4: J1.29; also elsewhere on the board
DIQ1_D5: J1.30; also elsewhere on the board
DIQ1_D6: J1.31; also elsewhere on the board
DIQ1_D7: J1.32; also elsewhere on the board
DIQ1_D8: J1.33; also elsewhere on the board
DIQ1_D9: J1.34; also elsewhere on the board
DIQ1_D10: J1.35; also elsewhere on the board
DIQ1_D11: J1.36; also elsewhere on the board
DIQ1_SEL: J1.19; also elsewhere on the board
DIQ2_D0: J1.43; also elsewhere on the board
DIQ2_D1: J1.44; also elsewhere on the board
DIQ2_D2: J1.45; also elsewhere on the board
DIQ2_D3: J1.46; also elsewhere on the board
DIQ2_D4: J1.49; also elsewhere on the board
DIQ2_D5: J1.50; also elsewhere on the board
DIQ2_D6: J1.51; also elsewhere on the board
DIQ2_D7: J1.52; also elsewhere on the board
DIQ2_D8: J1.53; also elsewhere on the board
DIQ2_D9: J1.54; also elsewhere on the board
DIQ2_D10: J1.55; also elsewhere on the board
DIQ2_D11: J1.56; also elsewhere on the board
DIQ2_SEL: J1.39; also elsewhere on the board
FCLK1: J1.60; also elsewhere on the board
FCLK2: J1.59; also elsewhere on the board
GND: J1.5, J1.6, J1.11, J1.12, J1.17, J1.18, J1.27, J1.28, J1.37, J1.38, J1.47, J1.48, J1.57, J1.58, J1.62, J1.63, J1.81, J1.82, J1.83, J1.84, J1.85, J1.86, J1.87, J1.88, J1.89 (GND), J1.90 (GND), P3.GND, P4.GND; also elsewhere on the board
RFDIO_GPIO0: J1.65; also elsewhere on the board
RFDIO_GPIO1: J1.67; also elsewhere on the board
RFDIO_GPIO2: J1.69; also elsewhere on the board
RFDIO_REF_CLK_IN: J1.75; also elsewhere on the board
RFDIO_RESET: J1.66; also elsewhere on the board
RFDIO_SPI_CLK: J1.72; also elsewhere on the board
RFDIO_SPI_EN: J1.74; also elsewhere on the board
RFDIO_SPI_MISO: J1.70; also elsewhere on the board
RFDIO_SPI_MOSI: J1.68; also elsewhere on the board
RXEN: J1.80; also elsewhere on the board
TXEN: J1.79; also elsewhere on the board

Parts:
C3, C4: 1µF; TantalC_SizeA_EIA-3216_HandSoldering
C5: 0.1µ; C_0603_HandSoldering
CON1: BARREL_JACK
D1: 5V-SOD-123F; SOD-123F_Handsoldering
F1: 2A-0603; C_0603_HandSoldering
J3: SELECT_DIV; Pin_Header_Straight_1x03; Manufacturer Part Number 68000-103HLF
JP1: LDO_1V2_IN_SEL; Pin_Header_Straight_1x03
Q1: Q_PMOS_GSD; SOT-23_Handsoldering
R5: R; R_0603_HandSoldering
U2: LD6815; SOT-753_(TSOP-5)_Handsoldering
U3: LTC1799; TSOT-23_Handsoldering

Connections:
1V2_LDO: C4.1, U2.5 (OUT); also elsewhere on the board
3V3_PMOD: JP1.3; also elsewhere on the board
5V: D1.1 (K), F1.2, JP1.1; also elsewhere on the board
5V_LDO_IN: C3.1, C5.1, J3.3, JP1.2, R5.2, U2.1 (IN), U2.3 (EN), U3.1 (VCC)
/power_supply/VIN: CON1.1, Q1.3
/power_supply/VIN_PROT: F1.1, Q1.2
GND: C3.2, C4.2, C5.2, CON1.2, CON1.3, D1.2 (A), J3.1, Q1.1, U2.2 (GND), U3.2 (GND); also elsewhere on the board
ICE_CLK_IN: U3.5 (OUT); also elsewhere on the board
unnamed: J3.2, U3.4 (DIV)
unnamed: R5.1, U3.3 (SET)

Notes on the sheet:
Reverse-polarity protection
Over current/voltage protection
Select 1V2 LDO input between 5V and 3V3 from PMOD
LDO to generate 1.2V supply voltage for iCE40
Clock generation

Parts:
J2: Pinheader_1x6_TH; Pin_Header_Straight_1x06; Manufacturer Part Number 68000-406HLF
R6, R9, R10, R11: 10k; R_0603_HandSoldering
U4: N25Q; SOP2-8_Handsoldering

Connections:
3V3_PMOD: J2.1, R6.1, R9.1, R10.1, R11.1, U4.8 (VDD); also elsewhere on the board
EXT_SPI_CLK: J2.4, R6.2, U4.6 (SCK); also elsewhere on the board
EXT_SPI_MISO: J2.2, U4.2 (SDO); also elsewhere on the board
EXT_SPI_MOSI: J2.5, U4.5 (SDI); also elsewhere on the board
EXT_SPI_SS_B: J2.3, R11.2, U4.1 (CS#); also elsewhere on the board
GND: J2.6, U4.4 (GND); also elsewhere on the board
unnamed: R9.2, U4.7 (HOLD#)
unnamed: R10.2, U4.3 (WP#)

Notes on the sheet:
SPI pin header
SPI flash memory
to iCE

Board: 2 copper layers, 76.2 x 48.8 mm, 58 parts (15 on the bottom side), 83 nets.

## Commit log

2016-01-22 Add README
2016-01-22 Start off with empty project
2016-01-25 Add libraries for ICE40 and Myriad connector
2016-01-25 Put in first instances
2016-01-25 Add own pmod schematic lib and footprint
2016-01-25 First pmod side wiring
2016-01-25 pmod wiring
2016-01-29 1.2V power supply
2016-01-29 removed obsolete lib
2016-01-29 added overcurrent/voltage protection
2016-01-29 added DIQ1 bus to RFDIO
2016-01-29 removed legacy footprints
2016-01-29 fixed RFDIO supply pins
2016-01-29 fixed polarity of jack
2016-01-29 added annotations
2016-02-03 DIQ1 Bus added
2016-02-06 DIQ2 Bus added
2016-02-08 control signals added
2016-02-10 spi & reset
2016-02-11 SPI & Osci
2016-02-13 minor changes
2016-02-13 missing SPI schematic
2016-02-15 3d model for hirose connector
2016-02-15 Finalize first draft
2016-02-16 Improve P&R
2016-02-17 Improve design
    * PMOS on input voltage for polarity
    * Re-design board to add mount holes and better routing
2016-02-18 3d model position update
2016-02-21 Add OSHW Logo
2016-02-21 Housekeeping
    Structure libraries and put proper licenses to them.
2016-02-21 Correct positioning of mount holes
2016-02-21 Fix silkscreen
2016-02-21 Add License
2016-04-21 changed n- to pmos
